# Keil uVision project Project.uvprojx, settings and files
target STM32L151CBT6A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151CBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L151xB,USE_HAL_DRIVER
  c include: ..\User\Inc;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_HAL_Driver\Inc;..\User\LoRaMac-node-master\boards;..\User\LoRaMac-node-master\boards\STM32L151CB;..\User\LoRaMac-node-master\mac;..\User\LoRaMac-node-master\mac\region;..\User\LoRaMac-node-master\peripherals\soft-se;..\User\LoRaMac-node-master\radio\sx126x;..\User\LoRaMac-node-master\radio;..\User\LoRaMac-node-master\system;..\User\LoRaMac-node-master;..\User\segger_rtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications/User
    ../User/Src/: main.c stm32l1xx_hal_msp.c system_stm32l1xx.c stm32l1xx_it.c system_time.c led.c key.c
  group Device
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xb.s
  group Libraries/STM32L1xx_HAL_Driver
    ../Libraries/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_usb.c stm32l1xx_ll_utils.c
  group lorawan_board
    ../User/LoRaMac-node-master/boards/STM32L151CB/: board.c delay-board.c rtc-board.c spi-board.c sx1262mbxcas-board.c utilities.c
  group lorawan_mac
    ../User/LoRaMac-node-master/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../User/LoRaMac-node-master/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group lorawan_peripherals
    ../User/LoRaMac-node-master/peripherals/soft-se/: aes.c cmac.c soft-se.c soft-se-hal.c
  group lorawan_radio
    ../User/LoRaMac-node-master/radio/sx126x/: radio.c sx126x.c
  group lorawan_system
    ../User/LoRaMac-node-master/system/: delay.c fifo.c systime.c timer.c
  group lorawan_demo
    ../User/Src/: lorawan_common.c lorawan_demo.c
  group segger_rtt
    ../User/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.5.0
